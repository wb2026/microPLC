# Keil uVision project microPLC.uvprojx, settings and files
target N32G435CB (6160000::V6.16::ARMCLANG)
  device: N32G435CB Nationstech
  pack: Nationstech.N32G43x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x6000) IRAM2(0x20006000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: microPLC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8002800 size 0x1c800
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x20006000 size 0x2000
  group src
    ./src/: boot.s bsp.c
